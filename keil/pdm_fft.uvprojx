# Keil uVision project pdm_fft.uvprojx, settings and files
target pdm_fft (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.2.0
  cpu: IRAM(0x10000000,0x00060000) IROM(0x0000C000,0x000F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: pdm_fft
  AfterMake: fromelf --bin --output bin\pdm_fft.bin bin\pdm_fft.axf
  AfterMake: fromelf -cedrst --output bin\pdm_fft.txt bin\pdm_fft.axf
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __FPU_PRESENT AM_UTIL_FAULTISR_PRINT AM_PART_APOLLO3 AM_PACKAGE_BGA UNITY_INCLUDE_CONFIG_H keil
  c include: ../../../bsp;../../../../..;../../../../../devices;../../../../../utils;../../../../../CMSIS/AmbiqMicro/Include;../../../../../CMSIS/ARM/Include;../../../../../mcu/apollo3;../src
  memory RVCT4: ROM 0xc000 size 0xf4000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\pdm_fft.sct
  link misc: ../../../../../mcu/apollo3/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: pdm_fft.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../mcu/apollo3/hal/keil/bin/: libam_hal.lib
    ../../../../../CMSIS/ARM/Lib/ARM/: arm_cortexM4lf_math.lib
  group devices
    ../../../../../devices/: am_devices_led.c am_devices_button.c
